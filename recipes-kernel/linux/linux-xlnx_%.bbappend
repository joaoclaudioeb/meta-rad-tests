FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://enable-htu.cfg \
            "
